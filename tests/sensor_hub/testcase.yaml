## tests/sensor_hub/testcase.yaml
```yaml
tests:
  sensor_hub.core:
    platform_allow:
      - native_sim
    tags:
      - kernel
      - sensor_hub
      - message_queue
```
